#include<iostream>
using namespace std;

int main()
{
    int n=12,k=0;
    char a[3][12] = {{'*','.','*','#','.','*','*','*','#','.','*','.'},{'*','.','*','#','.','.','*','.','#','*','*','*'},{'*','*','*','#','.','*','*','*','#','*','.','*'}};
    //  char a[3][18] = {{'*','.','*','#','*','*','*','#','*','*','*','#','*','*','*','.','*','.'},{'*','.','*','#','*','.','*','#','.','*','.','#','*','*','*','*','*','*'},{'*','*','*','#','*','*','*','#','*','*','*','#','*','*','*','*','.','*'}};
    for(int i=0;i<n;i++)
    {
        if(k>0)
        {
            k--;
            continue;
        }
            
        if(a[0][i]=='#')
        {
            std::cout<<'#';
            continue;
        }
        if(a[0][i] == '.')
            continue;
        
        if(a[0][i]=='*')
        {
            k=2; // something has been printed
            // for A
            if(i>0 && a[1][i-1]=='*' && a[1][i+1]=='*' && a[1][i]=='*')
                std::cout<<'A';
            else if(a[1][i]=='*' && a[1][i+1]=='*' && a[0][i+1]=='*')
                std::cout<<'E';
            else if(a[1][i]=='.' && a[1][i+1]=='*')
                std::cout<<'I';
            else if(a[1][i]=='*' && a[0][i+1]=='*' && a[1][i+1]=='.')
                std::cout<<'O';
            else if(a[1][i]=='*' && a[0][i+1]=='.')
                std::cout<<'U';
            else
                continue;
        }

    }
    return 0;
}